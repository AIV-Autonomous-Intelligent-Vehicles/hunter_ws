Commit message: Test

File: src/simulation/ugv_sim/hunter/hunter2_base/urdf/hunter2_base_gazebo.xacro (robot description, xacro)
@@ -371,5 +371,5 @@
     <axis
       xyz="0 0 -1" />
-     <dynamics damping="0.0" friction="15"/>
+    <dynamics damping="0.0" friction="15"/>
   </joint>
   <link
